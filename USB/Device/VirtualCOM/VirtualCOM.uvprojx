# Keil uVision project VirtualCOM.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.13.1.0
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x00000000,0x100000) XRAM(0x20000000,0x030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VirtualCOM
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: DEBUG, CPU_MK64FN1M0VLL12, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FRDM_K64F, FREEDOM, __MCUXPRESSO, SDK_DEBUGCONSOLE=DEBUGCONSOLE_REDIRECT_TO_TOOLCHAIN
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: board;source
  asm include: board;source
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group Board
    ./board/: board.c board.h pin_mux.c pin_mux.h clock_config.c clock_config.h
  group Source
    ./source/: main.c OTG_FS_MK64F.c USBD_FS_MK64F.c
  group Documentation
    ./: readme.txt Abstract.txt
software components: CMSIS Driver:USB Device:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX5 5.5.3, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, USB:CORE 6.15.0, USB:Device 6.15.0, USB:Device:CDC 6.15.0, Device:CMSIS:MK64F12_header 1.0.0, Device:CMSIS:MK64F12_system 1.0.0, Device:SDK Drivers:clock 2.5.1, Device:SDK Drivers:common 2.3.0, Device:SDK Drivers:debugconsole 1.0.0, Device:SDK Drivers:gpio 2.5.3, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:log 1.0.0, Device:SDK Drivers:smc 2.0.7, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_virtual 1.0.0, Device:Startup 1.1.0
