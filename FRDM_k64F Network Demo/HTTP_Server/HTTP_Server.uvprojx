# Keil uVision project HTTP_Server.uvprojx, settings and files
target DEBUG_MK64FN1M Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.12.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=1 uC99=1
  c define: DEBUG, CPU_MK64FN1M0VLL12, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc
  c include: board;source
  asm define: DEBUG
  asm include: board;source;CMSIS
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0xf000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Board
    ./Board/: clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h board.c board.h
  group Source
    ./: HTTP_Server.c HTTP_Server_CGI.c Buttons_FRDM_K64F.c Board_Buttons.h LED_FRDM_K64F.c Board_LED.h
    Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif logo.gif llblue.jpg pabb.gif
  group Documentation
    ./: Abstract.txt ReadMe.txt
software components: CMSIS Driver:Ethernet MAC:Custom 2.1.0, CMSIS Driver:Ethernet PHY:Custom 2.1.0, CMSIS Driver:Ethernet:Custom 2.1.0, CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.11.0, Network:Interface:ETH 7.11.0, Network:Service:Web Server Compact 7.11.0, Network:Socket:TCP 7.11.0, Network:Socket:UDP 7.11.0, CMSIS Driver:Ethernet:enet_cmsis 2.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.1.0, Device:SDK Drivers:dmamux 2.0.2, Device:SDK Drivers:dspi 2.2.1, Device:SDK Drivers:edma 2.1.8, Device:SDK Drivers:enet 2.2.4, Device:SDK Drivers:gpio 2.3.2, Device:SDK Drivers:i2c 2.0.7, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:phyksz8041 1.0.0, Device:SDK Drivers:port 2.1.0, Device:SDK Drivers:rcm 2.0.2, Device:SDK Drivers:rtc 2.2.0, Device:SDK Drivers:sim 2.1.0, Device:SDK Drivers:smc 2.0.5, Device:SDK Drivers:uart 2.1.6, Device:SDK Drivers:uart_adapter 1.0.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:Startup:MK64F12_startup 1.0.0
